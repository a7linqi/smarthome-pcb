# Keil uVision project LCD.uvprojx, settings and files
target JiaoHua-RTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: JiaoHuaRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,configUSE_IDLE_HOOK=0
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\DHT11;..\HARDWARE\ESP8266;..\HARDWARE\OLED;..\HARDWARE\KEY;..\HARDWARE\STMFLASH;..\HARDWARE\ADC;..\APP\Inc;..\Middlewares\FreeRTOS\Source\include;..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/KEY/: Key.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/ADC/: adc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group Application
    ../APP/Src/: app_main.c app_model.c sensor_task.c control_task.c key_task.c display_task.c comm_task.c
  group FreeRTOS Kernel
    ../Middlewares/FreeRTOS/Source/: tasks.c queue.c list.c
    ../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
